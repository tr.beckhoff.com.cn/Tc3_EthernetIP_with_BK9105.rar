PROGRAM MAIN
VAR
	DO_1 AT %QX0.0:BOOL;
	DO_2 AT %QX0.1:BOOL;
	Byte_DO AT %QB0:BYTE;
END_VAR

Byte_DO:=Byte_DO+1;

END_PROGRAM
